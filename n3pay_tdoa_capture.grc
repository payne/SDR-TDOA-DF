options:
  parameters:
    generate_options: qt_gui
    id: n3pay_tdoa_capture
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: noaa_station1.bin
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    clock_source0: gpsdo
    freq0: 162.4e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2.048e6
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
